EXTRA_OECMAKE:append:class-native = " -DCMAKE_SKIP_RPATH=ON"

